# Keil uVision project G0B1_WBR3.uvprojx, settings and files
target G0B1_WBR3 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G0B1RETx STMicroelectronics
  pack: Keil.STM32G0Bx_DFP.0.0.2
  cpu: IRAM(0x20000000-0x20023FFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: G0B1_WBR3 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G0B1xx
  c include: ../Core/Inc;    ../Drivers/STM32G0xx_HAL_Driver/Inc;    ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32G0xx/Include;    ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group Application/MDK-ARM
    ./: startup_stm32g0b1xx.s
  group Application/User/Core
    ../Core/Src/: mcu_api.c protocol.c system.c bsp_ws2812.c main.c gpio.c dma.c tim.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c user_button.c multi_button.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
software components: CMSIS:CORE 4.3.0
